FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0003-gl-renderer-add-WL_SHM_FORMAT_YUV420-WL_SHM_FORMAT_N.patch	\
			file://0004-compositor-set-DEFAULT_REPAINT_WINDOW-15.patch \
"
