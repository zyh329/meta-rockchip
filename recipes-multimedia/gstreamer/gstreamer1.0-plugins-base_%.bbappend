PV="1.10.2"

SRC_URI[md5sum] = "8efa9e9ad9a841a900359604da82fb8b"
SRC_URI[sha256sum] = "fbc0d40fcb746d2efe2ea47444674029912f66e6107f232766d33b722b97de20"
