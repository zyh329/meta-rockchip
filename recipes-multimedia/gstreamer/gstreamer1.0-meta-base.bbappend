RDEPENDS_gstreamer1.0-meta-base_remove = " \
    gstreamer1.0-plugins-good-souphttpsrc \
"

RDEPENDS_gstreamer1.0-meta-base_append = " \
    gstreamer1.0-plugins-good-soup \
"
